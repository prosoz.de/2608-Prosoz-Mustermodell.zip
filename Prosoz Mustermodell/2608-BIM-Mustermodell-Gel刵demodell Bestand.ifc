Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: D:/OneDrive - Planungsgruppe Drahtler GmbH/2780-Prosoz Mustermodell/BIM-Mustermodell-Geländemodell Bestand.ifc
Time: 2026-09-10T14:37:15
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2026 Update 7 (Build 879357) by Vectorworks, Inc.
Made in: Windows

# IfcProject: Vectorworks, Vectorworks Project
LongName: Vectorworks Project

# IfcSite, Geländemodell
LongName: Geländemodell; RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0
Qto_SiteBaseQuantities - GrossArea: 3543.95 m2; GrossPerimeter: 242894 mm
Pset_SiteCommon - Reference: Geländemodell

# IfcBuilding, Gebäude
Qto_BuildingBaseQuantities - GrossPerimeter: 0 mm; FootprintArea: 0 m2
BA_Allgemein - Bauherr Nachname: Bauherr Nachname; Bauherr Vorname: Bauherr Vorname; Bauherr Straße: Bauherr Straße; Bauherr Postleitzahl: Bauherr Postleitzahl; Bauherr Ort: Bauherr Ort; Entwurfsverfasser Nachname: Entwurfsverfasser Nachname; Entwurfsverfasser Vorname: Entwurfsverfasser Vorname; Entwurfsverfasser Straße: Entwurfsverfasser Straße; Entwurfsverfasser Postleitzahl: Entwurfsverfasser Postleitzahl; Entwurfsverfasser Ort: Entwurfsverfasser Ort; Gebäudeklasse: GK5; freistehend: yes; land- und forstwirtschaftliche Nutzung: no; Sonderbau: 0; Öffentliches Gebäude: yes
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 5; IsLandmarked: no

# IfcBuildingStorey (5)
In: Gebäude
Pset_BuildingStoreyCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2
Qto_BuildingStoreyBaseQuantities - NetHeight: 0 mm; GrossFloorArea: 0 m2; NetFloorArea: 0 m2
Name | Elevation (mm) | Classification | EntranceLevel | AboveGround = Vollgeschoss | Art
EX | 14000 | Dach (OmniClass) | no | no | Dachgeschoss
E0 | 0 | Geschoss (OmniClass) | yes | yes | Geschoss
E1 | 3500 | Geschoss (OmniClass) | no | yes | Geschoss
E2 | 7000 | Geschoss (OmniClass) | no | yes | Geschoss
E3 | 10500 | Geschoss (OmniClass) | no | yes | Geschoss

# IfcGeographicElement, Geländemodell
In: Geländemodell
PredefinedType: TERRAIN
