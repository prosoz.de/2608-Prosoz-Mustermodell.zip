Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: D:/OneDrive - Planungsgruppe Drahtler GmbH/2780-Prosoz Mustermodell/BIM-Mustermodell-BGF.ifc
Time: 2026-09-16T09:06:26
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2026 Update 7 (Build 879357) by Vectorworks, Inc.
Made in: Windows

# IfcProject: Vectorworks, Vectorworks Project
LongName: Vectorworks Project

# IfcSite, Geländemodell
LongName: Geländemodell; RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0
Qto_SiteBaseQuantities - GrossArea: 3543.95 m2; GrossPerimeter: 242894 mm
Pset_SiteCommon - Reference: Geländemodell

# IfcBuilding, Gebäude
Qto_BuildingBaseQuantities - GrossPerimeter: 0 mm; FootprintArea: 0 m2
BA_Allgemein - Bauherr Nachname: Bauherr Nachname; Bauherr Vorname: Bauherr Vorname; Bauherr Straße: Bauherr Straße; Bauherr Postleitzahl: Bauherr Postleitzahl; Bauherr Ort: Bauherr Ort; Entwurfsverfasser Nachname: Entwurfsverfasser Nachname; Entwurfsverfasser Vorname: Entwurfsverfasser Vorname; Entwurfsverfasser Straße: Entwurfsverfasser Straße; Entwurfsverfasser Postleitzahl: Entwurfsverfasser Postleitzahl; Entwurfsverfasser Ort: Entwurfsverfasser Ort; Gebäudeklasse: GK5; freistehend: yes; land- und forstwirtschaftliche Nutzung: no; Öffentliches Gebäude: yes
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 5; IsLandmarked: no

# IfcBuildingStorey (5)
In: Gebäude
Pset_BuildingStoreyCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2
Qto_BuildingStoreyBaseQuantities - NetHeight: 0 mm; GrossFloorArea: 0 m2; NetFloorArea: 0 m2
Name | Elevation (mm) | Classification | EntranceLevel | AboveGround = Vollgeschoss | Art
EX | 14000 | Dach (OmniClass) | no | no | Dachgeschoss
E0 | 0 | Geschoss (OmniClass) | yes | yes | Geschoss
E1 | 3500 | Geschoss (OmniClass) | no | yes | Geschoss
E2 | 7000 | Geschoss (OmniClass) | no | yes | Geschoss
E3 | 10500 | Geschoss (OmniClass) | no | yes | Geschoss

# IfcSpace: BGF (31)
PredefinedType: GFA
DA_ARC - geplante Fläche: 0.000000
BA_Raumobjekt - Objektverwendung: Bruttofläche
BA_DIN277_BGF - IstBGF: yes
Pset_SpaceCommon - Reference: BGF; GrossPlannedArea: 0 m2; NetPlannedArea: 0 m2
Name | In | LongName = Raumname = Raumnutzung | ElevationWithFlooring (mm) = Height (mm) | Lichte Höhe | OKFB | OKRB | Raumfläche | Raumnutzung nach DIN277 | UKFD | UKRD | IstNutzungseinheit | Nutzungsart | Raumumschließung | FinishCeilingHeight (mm) | GrossPerimeter (mm) = NetPerimeter (mm) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3) | Nutzungseinheit = Bezeichner | SpaceTemperatureMax (C) = SpaceTemperatureMin (C) = SpaceTemperatureSummerMax (C) = SpaceTemperatureSummerMin (C) = SpaceTemperatureWinterMax (C) = SpaceTemperatureWinterMin (C) = SpaceHumidity = SpaceHumiditySummer = SpaceHumidityWinter = NaturalVentilationRate = MechanicalVentilationRate = CoolingDesignAirflow = HeatingDesignAirflow = TotalSensibleHeatGain (W) = TotalHeatGain (W) = TotalHeatLoss (W) = CoolingDryBulb (C) = HeatingDryBulb (C) = VentilationAirFlowrate = ExhaustAirFlowrate = BoundaryAreaHeatLoss = ParkingUnits = OccupancyNumber = OccupancyNumberPeak = OccupancyTimePerDay (s) = AreaPerOccupant (m2) = MinimumHeadroom (mm) = Illuminance | OccupancyType
2 x  | EX | Technik | 2385 | 0.000000 | 14.000000 | 14.065000 | 88.502533 | BGF S - Brutto-Grundfläche S | 14.000000 | 16.450000 | no | undefiniert | Sonderfall | 0 | 42520 | 88.503 | 211.079 | 0
Space | E0 | TR 2 | 3500 | 3.500000 | 0.000000 | 0.000000 | 54.753259 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 33594 | 54.753 | 191.636 | 191.636 | TR 2 | 0 | Nicht definiert
Space | E0 | NE 1 | 3500 | 3.500000 | 0.000000 | 0.000000 | 285.320740 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 78278 | 285.321 | 998.623 | 998.623 | NE 1 | 0 | Nicht definiert
Space | E0 | NE 2 | 3500 | 3.500000 | 0.000000 | 0.000000 | 270.237065 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 72300 | 270.237 | 945.83 | 945.83 | NE 2 | 0 | Nicht definiert
Space | E0 | TR 1 | 3500 | 3.500000 | 0.000000 | 0.000000 | 54.744627 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 33789 | 54.745 | 191.606 | 191.606 | TR 1 | 0 | Nicht definiert
Space | E0 | NE 3 | 3500 | 3.500000 | 0.000000 | 0.000000 | 268.519785 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 104560 | 268.52 | 939.819 | 939.819 | NE 3 | 0 | Nicht definiert
Space | E0 | NE 5 | 3500 | 3.500000 | 0.000000 | 0.000000 | 285.283272 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 78078 | 285.283 | 998.491 | 998.491 | NE 5 | 0 | Nicht definiert
Space | E0 | NE 4 | 3500 | 3.500000 | 0.000000 | 0.000000 | 192.476997 | BGF R - Brutto-Grundfläche R | 3.500000 | 3.500000 | yes | Sonstiges | Regelfall | 3500 | 62174 | 192.477 | 673.669 | 673.669 | NE 4 | 0 | Nicht definiert
 | E0 | Auskragung | 3650 | 3.500000 | 0.000000 | -0.150000 | 167.845724 | BGF S - Brutto-Grundfläche S | 3.500000 | 3.500000 | no | Sonstiges | Sonderfall | 3500 | 248804 | 167.846 | 612.637 | 587.46
Space | E1 | TR 2 | 3500 | 3.500000 | 3.500000 | 3.500000 | 66.377372 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 42345 | 66.377 | 232.321 | 232.321 | TR 2 | 0 | Nicht definiert
Space | E1 | NE 6 | 3500 | 3.500000 | 3.500000 | 3.500000 | 294.541187 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 79296 | 294.541 | 1030.89 | 1030.89 | NE 6 | 0 | Nicht definiert
Space | E1 | NE 7 | 3500 | 3.500000 | 3.500000 | 3.500000 | 334.218482 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 81025 | 334.218 | 1169.77 | 1169.77 | NE 7 | 0 | Nicht definiert
Space | E1 | TR 1 | 3500 | 3.500000 | 3.500000 | 3.500000 | 68.286442 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 45380 | 68.286 | 239.003 | 239.003 | TR 1 | 0 | Nicht definiert
Space | E1 | NE 8 | 3500 | 3.500000 | 3.500000 | 3.500000 | 249.370960 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 66800 | 249.371 | 872.798 | 872.798 | NE 3 | 0 | Nicht definiert
Space | E1 | NE 10 | 3500 | 3.500000 | 3.500000 | 3.500000 | 294.447972 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 78998 | 294.448 | 1030.57 | 1030.57 | NE 5 | 0 | Nicht definiert
Space | E1 | NE 9 | 3500 | 3.500000 | 3.500000 | 3.500000 | 271.940983 | BGF R - Brutto-Grundfläche R | 7.000000 | 7.000000 | yes | Sonstiges | Regelfall | 3500 | 73225 | 271.941 | 951.793 | 951.793 | NE 4 | 0 | Nicht definiert
Space | E2 | TR 2 | 3500 | 3.500000 | 7.000000 | 7.000000 | 66.377372 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 42345 | 66.377 | 232.321 | 232.321 | TR 2 | 0 | Nicht definiert
Space | E2 | NE 11 | 3500 | 3.500000 | 7.000000 | 7.000000 | 294.541187 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 79296 | 294.541 | 1030.89 | 1030.89 | NE 1 | 0 | Nicht definiert
Space | E2 | NE 12 | 3500 | 3.500000 | 7.000000 | 7.000000 | 334.218482 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 81025 | 334.218 | 1169.77 | 1169.77 | NE 2 | 0 | Nicht definiert
Space | E2 | TR 1 | 3500 | 3.500000 | 7.000000 | 7.000000 | 68.286442 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 45380 | 68.286 | 239.003 | 239.003 | TR 1 | 0 | Nicht definiert
Space | E2 | NE 13 | 3500 | 3.500000 | 7.000000 | 7.000000 | 249.370960 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 66800 | 249.371 | 872.798 | 872.798 | NE 3 | 0 | Nicht definiert
Space | E2 | NE 15 | 3500 | 3.500000 | 7.000000 | 7.000000 | 294.447972 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 78998 | 294.448 | 1030.57 | 1030.57 | NE 5 | 0 | Nicht definiert
Space | E2 | NE 14 | 3500 | 3.500000 | 7.000000 | 7.000000 | 271.940983 | BGF R - Brutto-Grundfläche R | 10.500000 | 10.500000 | yes | Sonstiges | Regelfall | 3500 | 73225 | 271.941 | 951.793 | 951.793 | NE 4 | 0 | Nicht definiert
Space | E3 | TR 2 | 3715 | 3.350000 | 10.500000 | 10.500000 | 66.377372 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 42345 | 66.377 | 246.592 | 222.364 | TR 2 | 0 | Nicht definiert
Space | E3 | NE 16 | 3715 | 3.350000 | 10.500000 | 10.500000 | 294.541187 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 79296 | 294.541 | 1094.22 | 986.713 | NE 1 | 0 | Nicht definiert
Space | E3 | NE 12 | 3715 | 3.350000 | 10.500000 | 10.500000 | 334.218482 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 81025 | 334.218 | 1241.62 | 1119.63 | NE 2 | 0 | Nicht definiert
Space | E3 | TR 1 | 3715 | 3.350000 | 10.500000 | 10.500000 | 68.286442 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 45380 | 68.286 | 253.684 | 228.76 | TR 1 | 0 | Nicht definiert
Space | E3 | NE 17 | 3715 | 3.350000 | 10.500000 | 10.500000 | 249.370960 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 66800 | 249.371 | 926.413 | 835.393 | NE 3 | 0 | Nicht definiert
Space | E3 | NE 19 | 3715 | 3.350000 | 10.500000 | 10.500000 | 294.447972 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 78998 | 294.448 | 1093.87 | 986.401 | NE 5 | 0 | Nicht definiert
Space | E3 | NE 18 | 3715 | 3.350000 | 10.500000 | 10.500000 | 271.940983 | BGF R - Brutto-Grundfläche R | 13.850000 | 14.215000 | yes | Sonstiges | Regelfall | 3350 | 73225 | 271.941 | 1010.26 | 911.002 | NE 4 | 0 | Nicht definiert

# IfcBuildingElementProxy: DA SY Projektnullpunkt - Rotationswinkel (2)
In: Geländemodell
PredefinedType: USERDEFINED; Material: Default
DA_ARC - Status: Neu
BA_Proxy - Objektverwendung: Referenzpunkt
BA_Bauteil - Außenbauteil: no; Gebäudehülle: no; tragend: no; Status: Neu; Denkmalschutz: no
Name
Projektnullpunkt
mittlere Geländehöhe | BA_Referenzpunkt - Mittlere Geländehöhe: yes
